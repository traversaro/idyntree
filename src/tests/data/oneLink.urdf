Commit message: Add InertialParametersHelpers and related assimp dependency

File: src/tests/data/oneLink.urdf (robot description, URDF)
Before this commit: robot oneLink, 4 links, 3 joints
Links:
- link link1: geometry collision mesh filename=cube.stl; visual mesh filename=cube.stl
